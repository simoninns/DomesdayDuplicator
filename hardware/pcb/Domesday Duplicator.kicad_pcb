# Repository simoninns/DomesdayDuplicator

File README.md:

# Domesday Duplicator (DdD)

The Domesday Duplicator is a LaserDisc capture focused, USB 3.0 based DAQ capable of 40
million samples per second acquisition of analogue RF data at 10-bits resolution.

Please see the [Project Documentation](https://simoninns.github.io/DomesdayDuplicator/) for
details of the project and for access to the project documentation. For contributing
guidelines, see [CONTRIBUTING.md](CONTRIBUTING.md).

## The capture application

Capture is via an easy to use GUI capture application, with real-time signal analysis —
waveform, spectrum analyser and spectrogram, amplitude history and live capture statistics —
so you can see the RF while it is being sampled rather than after the fact.

The application also drives a Pioneer LaserDisc player over serial, runs whole-disc automatic
captures, and updates the Duplicator's own firmware and gateware over USB. The
[Capture Application documentation](https://simoninns.github.io/DomesdayDuplicator/capture-gui/)
covers every panel.

## Installing — no compilation required

**There is absolutely no need to compile anything.** All end-user installs must be performed
using the provided binary packages and firmware images. Building from source is a development
activity only, and nothing you need as a user requires it.

### The capture application

Download from the [releases page](https://github.com/simoninns/DomesdayDuplicator/releases)
and follow the installation page for your platform:

| Platform | Package | Installation |
| --- | --- | --- |
| Linux | `DomesdayDuplicator-<version>.flatpak` | [Linux (Flatpak)](https://simoninns.github.io/DomesdayDuplicator/capture-gui/install-flatpak/) |
| macOS (Apple Silicon) | `DomesdayDuplicator-<version>-macos-arm64.dmg` | [macOS (DMG)](https://simoninns.github.io/DomesdayDuplicator/capture-gui/install-dmg/) |
| Windows 11 | `DomesdayDuplicator-<version>-windows-x64.msi` | [Windows (MSI)](https://simoninns.github.io/DomesdayDuplicator/capture-gui/install-msi/) |

Every release also carries `SHA256SUMS` and a `PROVENANCE.txt` recording the commit each
asset was built from. Verify your download against `SHA256SUMS`.

### Firmware and gateware

You do not build these either. Firmware releases publish a single signed update bundle,
`domesday-duplicator-update-<version>.dddfw`, and the capture application installs it for you:
**Tools → Firmware → Update firmware…**. The application verifies the bundle's signature and
every payload digest before it writes anything, and reports the version it reads back off the
live device afterwards. See
[Updating your Domesday Duplicator](https://simoninns.github.io/DomesdayDuplicator/capture-gui/updating-your-domesday-duplicator/).

A board that has never been programmed is handled the same way, with no jumper and no shell —
see [Bringing up a new or legacy board](https://simoninns.github.io/DomesdayDuplicator/capture-gui/bringing-up-a-board/).
Firmware releases also publish the raw images (`firmware.img`, the provisioning `.jic` and the
factory `.svf`) for bench recovery, but the bundle is the supported route.

Every released artefact is built by CI from the tagged commit; nothing is built on a
maintainer's machine or attached by hand
([release pipeline](https://simoninns.github.io/DomesdayDuplicator/development/release-pipeline/)).

## Cloning the repository

Everything is in this one repository. There are no git submodules, so a plain clone gives
you the complete project:

```
git clone https://github.com/simoninns/DomesdayDuplicator.git
```

### Repository layout

| Directory | Contents |
| --- | --- |
| [hardware/](hardware/) | KiCad design for the custom DdD board, plus hardware documentation |
| [fpga/](fpga/) | Verilog gateware for the Terasic DE0-NANO (Cyclone IV) |
| [fx3/firmware/](fx3/firmware/) | Cypress FX3 USB 3.0 controller firmware |
| [fx3/programmer/](fx3/programmer/) | Host-side tool for programming the FX3 |
| [fx3/mkimage/](fx3/mkimage/) | `fx3-mkimage`, the project's own ELF-to-boot-image tool |
| [fx3/sdk/](fx3/sdk/) | Vendored Cypress FX3 SDK the firmware builds against |
| [ddd-gui/](ddd-gui/) | Qt 6 capture application, and the Flatpak/DMG/MSI packaging under `ddd-gui/packaging/` |
| [docs/](docs/) | Source of the project documentation website |
| [docs-vendor/](docs-vendor/) | Transcribed vendor service documentation for supported players |
| [nix/](nix/) | The single flake's shared helpers, default dev shell, NixOS module and whole-tree checks |
| [tools/](tools/) | Repository-wide scripts, run both by hand and by the checks |

## Developing the project

**Do NOT install from source unless you intend to develop the software** — see
[Installing](#installing--no-compilation-required) above for user installations.

### Nix on Linux is the only supported environment

**The only supported development and build environment is Nix on Linux.** There is exactly one
`flake.nix`, at the repository root, and exactly one `flake.lock`; every toolchain the project
needs is pinned by it, and CI builds through the same flake, so a build that fails under Nix
is a real failure rather than an environment quirk.

**Pull requests that introduce another development or build environment will not be accepted.**
That includes alternative build systems, per-distribution dependency lists, and packaging
intended to make a component build without Nix. If you develop on macOS or Windows, use a
Linux virtual machine — that is the supported route, and it is the only one.

### Building

Run any of these from anywhere in the working tree; Nix walks up to find the flake at the
root, so `.#ddd-gui` resolves identically from `ddd-gui/` and from the repository root.

| Component | Build | Development shell |
| --- | --- | --- |
| Capture application | `nix build .#ddd-gui` | `nix develop .#ddd-gui` |
| FX3 firmware | `nix build .#fx3-firmware` | `nix develop .#fx3` |
| FX3 programmer | `nix build .#fx3-programmer` | `nix develop .#fx3` |
| FX3 boot-image tool | `nix build .#fx3-mkimage` | `nix develop .#fx3` |
| FPGA gateware | `nix build .#bitstream` | `nix develop .#fpga` · `nix develop .#fpga-quartus` |
| Documentation site | `nix build .#docs-site` | `nix develop .#docs` |
| PCB | — | `nix develop .#hardware` |

```
nix develop                          # every component's tools in one shell
nix flake check                      # build everything and run the whole T1–T4 test suite
```

The capture application installs three binaries: `ddd-gui`, plus `ddd-update` and `ddd-jtag`,
which drive the same engine from a shell.

Components deliberately carry no flake of their own: an earlier layout gave each one a thin
flake for the `cd ddd-gui && nix develop` shorthand, and every one of those resolved
`nixos-unstable` into a lock file of its own — so entering the tree through a component quietly
got a different nixpkgs from the root pin. The reasoning is in the header comment of
[flake.nix](flake.nix).

Two caveats on the FPGA row. Quartus Prime Lite is unfree, `x86_64-linux` only and cannot be
served from a binary cache, so `nix build .#bitstream` means a multi-gigabyte first download
and is excluded from `nix flake check` — the per-commit tier must never require an unfree
download of anyone. It *is* built by CI, in a workflow of its own that runs on gateware
changes and from release tags, so every released bitstream is CI-built from the tagged commit.
`nix develop .#fpga` — without `-quartus` — gives the free tools instead: Verilog lint,
simulation and a language server, with no Quartus at all, and that covers most gateware work.

Build directories are `build/` under each component and are gitignored. Never build in-tree:
in the gateware's project directories in particular, Quartus rewrites the tracked `.qsf` on
every compile.

On NixOS, device permissions come from the flake's module — set
`hardware.domesdayDuplicator.enable = true;`, which covers the Duplicator, the FX3 and the
on-board USB-Blaster together. Elsewhere, see
[Linux device access](https://simoninns.github.io/DomesdayDuplicator/development/hardware-programming/linux-device-access/).

[AGENTS.md](AGENTS.md) records the project conventions and [TESTING.md](TESTING.md) the test
tiers, including the hardware-in-the-loop capture-integrity procedure that is the most
important test in the project.

## The Decode Family

The samples the DdD captures can be used with the whole family of decoders that make the FM RF
archival workflow ready to use today.

The original design was for the wide bandwidth of LaserDisc RF — making it suitable for all of
the more bandwidth restricted mediums too (that have a single stream of RF).

[Please see the documentation for more details](https://simoninns.github.io/DomesdayDuplicator/general/overview/)

## 3D Printed Case

The Domesday Duplicator also has [3D models](https://github.com/simoninns/DomesdayDuplicator-Case)
and ready to use STL files for producing 3D printed cases, to protect from dust or line with
copper tape for affordable EMI shielding for example.

## Authors

Domesday Duplicator is designed and maintained by [Simon Inns](https://github.com/simoninns).

## Licences

- [Software Licence — GPLv3](LICENSE)
- [Hardware Licence — Creative Commons BY-SA 4.0](https://creativecommons.org/licenses/by-sa/4.0/)
  (full text in [hardware/pcb/LICENSE.txt](hardware/pcb/LICENSE.txt))

## KiCad design hardware/pcb/Domesday Duplicator.kicad_pcb

File hardware/README.md:

# Domesday Duplicator Hardware

Design files for the custom Domesday Duplicator PCB — the analogue front end, ADC and
interconnect that sit between the RF source and the DE0-NANO/FX3 boards.

## Contents

| Path | Contents |
| --- | --- |
| [pcb/](pcb/) | KiCad project: schematics, PCB layout, symbol and footprint libraries |
| [pcb/fab/](pcb/fab/) | Fabrication outputs, one frozen directory per board revision |
| [pcb/tools/](pcb/tools/) | Plotting and Gerber comparison scripts |
| [doc/](doc/) | Hardware documentation, including the gain and filter calculations |

The project is on the current KiCad format (10). Board revisions are recorded in
[pcb/CHANGELOG.md](pcb/CHANGELOG.md), and [pcb/MIGRATION.md](pcb/MIGRATION.md) documents the
conversion from the original KiCad 4 files, how it was verified, and what is still
outstanding.

Schematic PDFs and the BOM are not kept in the repository. They are build output, plotted
per revision into `pcb/fab/rev<REV>/` by the script below, and can be regenerated from the
project at any time.

## Design

The Domesday Duplicator hardware is based on:

- Terasic DE0-NANO FPGA development board (see [fpga/](../fpga/))
- Cypress FX3 USB 3.0 controller (see [fx3/](../fx3/))
- High-speed ADC for RF signal capture
- Custom analogue front-end circuitry

## Manufacturing

Each fabricated board revision has its own directory under `pcb/fab/`, holding the Gerbers
and drill file exactly as sent out, the schematic PDF and BOM they were built from, a
`MANIFEST.md` recording provenance, and a `SHA256SUMS`. These are a historical record, not
build output: they are written once and never regenerated, because they are the reference
for what the working board actually is.

`pcb/fab/rev1.0/` is the proven production board, plotted with KiCad 4.0.7 in 2018. A
modern KiCad cannot reproduce it byte for byte — it encodes zone fills differently — which
is why it is preserved rather than rebuilt.

To plot a new revision:

```sh
nix develop .#hardware
hardware/pcb/tools/plot-fab.sh 2.0
```

The script refuses to write into a revision directory that already exists. To compare a
fresh plot against an existing one, plot with `--scratch` and use
`pcb/tools/gerber-compare.py`, which compares geometry rather than text and so ignores the
aperture renumbering and object reordering that make a plain diff useless.

## Licence

The hardware design is licensed under **Creative Commons Attribution-ShareAlike 4.0
International**. The full text is in [pcb/LICENSE.txt](pcb/LICENSE.txt).

This is different from the software in this repository, which is GPLv3 — see the root
[LICENSE](../LICENSE).

## Documentation

For detailed documentation, please see the
[main project documentation](https://simoninns.github.io/DomesdayDuplicator).

Board: 2 copper layers, 95.2 x 57.2 mm, 59 parts (2 on the bottom side), 91 nets.

Parts:
C301, C303, C305, C307, C309, C311, C313, C314, C316, C317, C318, C401, C402, C408, C502, C504: 100nF; C_0805
C302, C304, C306, C308, C310, C312, C315, C319, C409: 2.2uF Tant; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C403: 330pF; C_0805
C404: 33pF; C_0805
C405: 470pF; C_0805
C406: 100pF; C_0805
C407: 270pF; C_0805
C501, C503: 10uF TANT; CP_Tantalum_Case-B_EIA-3528-21_Reflow
J101: DE0-Nano_GPIO1; Socket_Strip_Straight_2x20_Pitch2.54mm
J102: DE0-Nano_GPIO0; Socket_Strip_Straight_2x20_Pitch2.54mm
J201: GPIFII_J7; Pin_Header_Straight_2x20_Pitch2.54mm
J202: GPIFII_J6; Pin_Header_Straight_2x20_Pitch2.54mm
J401: BNC_Rosenberger; BNC Socket
L401: 680nH; L_0805
L402: 560nH; L_0805
L501: 100uH; Inductor_Bourns-SRU8043
R301, R402, R403, R407: 1K; R_0805
R302: 1K2; R_0805
R401: 56R; R_0805
R404: 100R; R_0805
R405: 200R; R_0805
R406: 1K5; R_0805
R408: 680R; R_0805
R409: 560R; R_0805
R410, R411: 47R; R_0805
SW401: Gain Select; SW_DIP_x4_W7.62mm_Slide_Copal_CHS-B
U301: ADS825; SSOP-28_5.3x10.2mm_Pitch0.65mm
U302, U303: 74LVTH541_PWR; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U401: OPA690; SOIC-8_3.9x4.9mm_Pitch1.27mm
U501: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3.3VA: C316.1, C317.1, C318.1, C319.1, C503.1, C504.1, U301.28, U302.20, U303.20, U501.2
+5V: J101.11, J102.11, J202.3, J202.4, L501.2
+5VA: C313.1, C314.1, C315.1, C408.1, C409.1, C501.1, C502.1, L501.1, U301.15, U301.17, U301.27, U401.7, U401.8, U501.3
/ADC/IN: R411.2, U301.25
/ADC/REFB: C309.1, C310.1, R302.1, R403.1, U301.19
/ADC/REFT: C307.1, C308.1, R301.2, R402.2, U301.22
ADC_CLK: J102.40, U301.14
ADC_DATA0: J102.39, U302.18
ADC_DATA1: J102.38, U302.17
ADC_DATA2: J102.37, U302.16
ADC_DATA3: J102.36, U302.15
ADC_DATA4: J102.35, U302.14
ADC_DATA5: J102.34, U302.13
ADC_DATA6: J102.33, U302.12
ADC_DATA7: J102.32, U302.11
ADC_DATA8: J102.31, U303.18
ADC_DATA9: J102.28, U303.17
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C402.2, C403.2, C405.2, C407.2, C408.2, C409.2, C501.2, C502.2, C503.2, C504.2, J101.12, J101.30, J102.12, J102.30, J201.13, J201.15, J201.17, J201.25, J201.29, J201.39, J201.40, J202.6, J202.33, J202.37, J401.2, J401.3, J401.4, J401.5, R401.1, U301.1, U301.12, U301.13, U301.16, U301.18, U301.26, U302.1, U302.10, U302.19, U303.1, U303.4, U303.5, U303.6, U303.7, U303.8, U303.9, U303.10, U303.19, U401.4, U501.1
unnamed: C301.1, C302.1, U301.21
unnamed: C303.1, C304.1, U301.20
unnamed: C305.1, C306.1, R301.1, R302.2, U301.24
unnamed: C311.1, C312.1, U301.23
unnamed: C401.1, R402.1, R403.2, R404.1
unnamed: C401.2, J401.1, R401.2
unnamed: C402.1, R405.1
unnamed: C403.1, C404.1, L401.2, R410.2
unnamed: C404.2, C405.1, C406.1, L401.1, L402.2
unnamed: C406.2, C407.1, L402.1, R411.1
unnamed: R404.2, U401.3
unnamed: R405.2, R406.1, R407.1, R408.1, R409.1, U401.2
unnamed: R406.2, SW401.1
unnamed: R407.2, SW401.2
unnamed: R408.2, SW401.3
unnamed: R409.2, SW401.4
unnamed: R410.1, SW401.5, SW401.6, SW401.7, SW401.8, U401.6
unnamed: U301.2, U303.3
unnamed: U301.3, U303.2
unnamed: U301.4, U302.9
unnamed: U301.5, U302.8
unnamed: U301.6, U302.7
unnamed: U301.7, U302.6
unnamed: U301.8, U302.5
unnamed: U301.9, U302.4
unnamed: U301.10, U302.3
unnamed: U301.11, U302.2
USB_CTL0: J101.34, J202.31
USB_CTL1: J101.32, J202.29
USB_CTL2: J101.28, J202.27
USB_CTL3: J101.26, J202.25
USB_CTL4: J101.24, J202.23
USB_CTL5: J101.22, J202.21
USB_CTL6: J101.20, J202.19
USB_CTL7: J101.18, J202.17
USB_CTL8: J101.16, J202.15
USB_CTL9: J101.14, J202.13
USB_CTL10: J101.10, J202.11
USB_CTL11: J101.8, J202.9
USB_CTL12: J101.6, J202.7
USB_DATA0: J101.39, J202.38
USB_DATA1: J101.37, J202.36
USB_DATA2: J101.35, J202.34
USB_DATA3: J101.33, J202.32
USB_DATA4: J101.31, J202.30
USB_DATA5: J101.27, J202.28
USB_DATA6: J101.25, J202.26
USB_DATA7: J101.23, J202.24
USB_DATA8: J101.21, J202.22
USB_DATA9: J101.19, J202.20
USB_DATA10: J101.17, J202.18
USB_DATA11: J101.15, J202.16
USB_DATA12: J101.13, J202.14
USB_DATA13: J101.9, J202.12
USB_DATA14: J101.7, J202.10
USB_DATA15: J101.5, J202.8
USB_DATA16: J102.5, J201.38
USB_DATA17: J102.6, J201.36
USB_DATA18: J102.7, J201.34
USB_DATA19: J102.8, J201.32
USB_DATA20: J102.9, J201.30
USB_DATA21: J102.10, J201.28
USB_DATA22: J102.17, J201.26
USB_DATA23: J102.18, J201.24
USB_DATA24: J102.19, J201.22
USB_DATA25: J102.20, J201.20
USB_DATA26: J102.21, J201.18
USB_DATA27: J102.22, J201.16
USB_DATA28: J102.23, J201.12
USB_DATA29: J102.24, J201.10
USB_DATA30: J102.25, J201.8
USB_DATA31: J102.26, J201.6
USB_PCLK: J101.38, J202.35

## KiCad design KiCAD/Domesday Duplicator/Domesday Duplicator.kicad_pcb

Board: 2 copper layers, 91.4 x 55.9 mm, 48 parts (2 on the bottom side), 84 nets.

Parts:
C1, C3, C5, C6, C7, C10, C12, C13, C14, C16, C18, C20, C22, C24, C25, C27: 100nF; C_0805
C2, C8, C9, C15, C17, C19, C21, C23, C28: 2.2uF Tant; CP_Tantalum_Case-A_EIA-3216-18_Reflow
C4, C11: 10uF; CP_Elec_4x5.7
C26: 220pF (1%); C_0805
J1: DE0-Nano_GPIO0; Socket_Strip_Straight_2x20_Pitch2.54mm
J2: DE0-Nano_GPIO1; Socket_Strip_Straight_2x20_Pitch2.54mm
J3: GPIFII_J7; Pin_Header_Straight_2x20_Pitch2.54mm
J4: GPIFII_J6; Pin_Header_Straight_2x20_Pitch2.54mm
J5: BNC_Rosenberger; BNC Socket
L1: 100uH; Inductor_Bourns-SRU8043
R1: 100R; R_0805
R2, R3, R7, R8: 1K62; R_0805
R4: 220R; R_0805
R5: 1K2; R_0805
R6: 47R; R_0805
R9: NF; R_0805
U1: LM1117-3.3; SOT-223
U2: ADS825; SSOP-28_5.3x10.2mm_Pitch0.65mm
U3, U4: 74LVTH541_PWR; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U5: OPA690; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+3.3VA: C10.1, C11.1, C13.1, C14.1, C16.1, C17.1, U1.2, U1.4, U2.28, U3.20, U4.20
+5V: J1.11, J2.11, J4.3, J4.4, L1.2
+5VA: C3.1, C4.1, C5.1, C7.1, C8.1, C22.1, C23.1, L1.1, U1.3, U2.15, U2.17, U2.27, U5.7, U5.8
/ADC/IN: C26.1, R6.1, U2.25
/ADC/REFB: C20.1, C21.1, R3.1, R8.1, U2.19
/ADC/REFT: C18.1, C19.1, R2.2, R7.2, U2.22
ADC_CLK: J1.40, U2.14
ADC_DATA0: J1.39, U3.18
ADC_DATA1: J1.38, U3.17
ADC_DATA2: J1.37, U3.16
ADC_DATA3: J1.36, U3.15
ADC_DATA4: J1.35, U3.14
ADC_DATA5: J1.34, U3.13
ADC_DATA6: J1.33, U3.12
ADC_DATA7: J1.32, U3.11
ADC_DATA8: J1.31, U4.18
ADC_DATA9: J1.28, U4.17
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, J1.12, J1.30, J2.12, J2.30, J3.13, J3.15, J3.17, J3.29, J3.39, J3.40, J4.6, J4.33, J4.37, J5.2, J5.3, J5.4, J5.5, U1.1, U2.1, U2.12, U2.13, U2.16, U2.18, U2.26, U3.1, U3.10, U3.19, U4.1, U4.10, U4.19, U5.4
unnamed: C1.1, C2.1, U2.21
unnamed: C6.1, C9.1, U2.20
unnamed: C12.1, C15.1, R7.1, R8.2, R9.2, U2.24
unnamed: C24.1, R1.2
unnamed: C24.2, J5.1
unnamed: C25.1, R4.1
unnamed: C27.1, C28.1, R9.1, U2.23
unnamed: R1.1, R2.1, R3.2, U5.3
unnamed: R4.2, R5.1, U5.2
unnamed: R5.2, R6.2, U5.6
unnamed: U2.2, U4.3
unnamed: U2.3, U4.2
unnamed: U2.4, U3.9
unnamed: U2.5, U3.8
unnamed: U2.6, U3.7
unnamed: U2.7, U3.6
unnamed: U2.8, U3.5
unnamed: U2.9, U3.4
unnamed: U2.10, U3.3
unnamed: U2.11, U3.2
USB_CTL0: J2.34, J4.31
USB_CTL1: J2.32, J4.29
USB_CTL2: J2.28, J4.27
USB_CTL3: J2.26, J4.25
USB_CTL4: J2.24, J4.23
USB_CTL5: J2.22, J4.21
USB_CTL6: J2.20, J4.19
USB_CTL7: J2.18, J4.17
USB_CTL8: J2.16, J4.15
USB_CTL9: J2.14, J4.13
USB_CTL10: J2.10, J4.11
USB_CTL11: J2.8, J4.9
USB_CTL12: J2.6, J4.7
USB_DATA0: J2.39, J4.38
USB_DATA1: J2.37, J4.36
USB_DATA2: J2.35, J4.34
USB_DATA3: J2.33, J4.32
USB_DATA4: J2.31, J4.30
USB_DATA5: J2.27, J4.28
USB_DATA6: J2.25, J4.26
USB_DATA7: J2.23, J4.24
USB_DATA8: J2.21, J4.22
USB_DATA9: J2.19, J4.20
USB_DATA10: J2.17, J4.18
USB_DATA11: J2.15, J4.16
USB_DATA12: J2.13, J4.14
USB_DATA13: J2.9, J4.12
USB_DATA14: J2.7, J4.10
USB_DATA15: J2.5, J4.8
USB_DATA16: J1.5, J3.38
USB_DATA17: J1.6, J3.36
USB_DATA18: J1.7, J3.34
USB_DATA19: J1.8, J3.32
USB_DATA20: J1.9, J3.30
USB_DATA21: J1.10, J3.28
USB_DATA22: J1.17, J3.26
USB_DATA23: J1.18, J3.24
USB_DATA24: J1.19, J3.22
USB_DATA25: J1.20, J3.20
USB_DATA26: J1.21, J3.18
USB_DATA27: J1.22, J3.16
USB_DATA28: J1.23, J3.12
USB_DATA29: J1.24, J3.10
USB_DATA30: J1.25, J3.8
USB_DATA31: J1.26, J3.6
USB_PCLK: J2.38, J4.35

## Commit log (part)

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2022-09-09 New feature: Inbound RF amplitude measurement
2022-09-09 Disable 16 bit processing when 10 bit is enabled but amplitude text/graph is disabled
2022-09-09 Attribution for QCustomPlot
2022-09-10 Remove unneeded QChart dependency
2022-10-01 Specify the C++ version being used explicitly.
2022-10-01 Allow the Qt version to be specified explicitly.
    This adds USE_QT_VERSION, which allows the test suite, or a packager, to
    avoid fallback in the case that the intended version isn't found.
2022-10-01 Specify CMAKE_BUILD_TYPE for the CI.
2022-12-14 Fixed Cmake
2022-12-14 Added Qt multimedia dependency
2022-12-16 Added amplitude files to Qt project
2022-12-16 Updated to support graph in main window
2022-12-16 Remove Qt5
2022-12-17 Persist notes/mint markings when changing sides
2022-12-18 Add copyright notices to new files.
2022-12-18 Remove unused code.
2022-12-18 sizeof(char) is always 1.
2022-12-18 Restructure functions to update amplitude UI.
    Only one of these needs to be a slot, and there's no need to create a
    new QTimer each time the configuration is changed.
2022-12-19 Rework how amplitude buffers are captured.
    Previously, when an amplitude display was enabled, the UsbCapture thread
    converted every disk buffer into 16-bit form and copied it to a
    temporary buffer, which was very expensive, and meant it had to know
    whether the display was enabled.
    Now it's done on request: the static function that returns a disk buffer
    gives back the most recently-captured one, and sets a flag saying that a
2022-12-19 Make getMeanAmplitude more efficient.
    The main improvement here comes from simplifying the loop that computes
    the RMS value; I've also used std::array rather than QList for the
    smoothing (which doesn't really matter since it's only done once a
    second).
2022-12-19 Reenable Qt 5 tests.
    Note that these are also testing the oldest version of Ubuntu we
    support.
2022-12-26 Find PkgConfig before using it.
    This may be pulled in by one of the earlier packages (e.g. Qt 6), but
    this file shouldn't rely on that.
2022-12-26 Make the build work with both Qt 5 and Qt 6.
    The oldest version we support is Qt 5.12, which is missing some of the
    compatibility definitions introduced in 5.15. Emulate these so we don't
    need to specify the Qt version in the subdirectories.
2022-12-26 updated readme to point to new project wiki
2022-12-26 Add a top-level CMakeLists.txt.
2022-12-26 Add cmake build files and module for finding libusb borrowed from libfreenect
2022-12-26 Move duplicated checks into the top-level CMakeLists.txt.
2022-12-26 Tidy some blank lines.
2022-12-26 More .gitignore rules for CMake.
2022-12-26 Add a top-level .pro file, to build all the tools.
2022-12-26 Add GitHub CI workflow.
    This tests with Qt 5 on Ubuntu 20.04, and Qt 6 on Ubuntu 22.04.
2022-12-26 Add GitHub CI workflow.
    This builds with Qt 5 on the oldest Ubuntu we support, and with Qt 6 on
    the latest that GitHub provides. It's limited by path to only run for
    commits that change Linux-Application, not the other subdirs.
2022-12-26 Mark DomesdayDuplicator as WIN32.
    I don't know if it will work on Windows at the moment, but if it does
    then (like dddutil) it needs flagging as having a GUI.
2022-12-26 Use (correct) default installation paths.
2022-12-26 Reduce minimum CMake version to 3.13.
    This is the version in Debian buster; we don't appear to need any newer
    features.
2022-12-26 Make qt_add_resources work for Qt 5.
    Passing filenames directly to this, rather than using a .qrc file, only
    works with Qt 6 (and Qt 5's CMake rules don't complain about arguments
    they don't recognise), so Qt 5 builds were missing resources.
    Tested with Qt 5.11, 5.15 and 6.3.
2022-12-26 Don't enable CMAKE_INCLUDE_CURRENT_DIR.
    It's not needed for any of the code.
2022-12-26 Add .gitignore entries for building with ninja.
    The make and ninja generators are both fairly commonly used.
2022-12-26 Fixed VirtualLock failed return code
2022-12-26 Add Windows support to new page lock features
2022-12-26 segregate windows code only
2022-12-26 Don't specify a version number in CMakeLists.txt.
2022-12-26 Update copyright years in About dialogs.
2023-01-09 Fix sequence number synchronisation when the counter wraps.
    The initial synchronisation would occasionally fail, saying "expecting
    65535 but got 62" in the debug log. This happened if the first sequence
    number change in the disk buffer was from 62 to 0, since in that case
    the value at the start of the buffer should be 62, not -1.
    Fix this by checking explicitly for 0.
2023-01-09 Give most UI widgets sensible names.
    Most of these are anonymous labels. I've renamed the "number of disk
    buffers written" label to match what the code actually uses it for now.
2023-01-10 Rebuild the main window using layouts.
    This looks tidier for the newly-added amplitude bits, and it adapts
    better when the window size is increased.
2023-01-10 Rebuild the configuration window using layouts.
    This should look much the same as before, except that I've moved the
    Browse button for the output directory onto the same line as the edit
    box.
2023-01-10 Avoid relying on integer promotion.
    It's vanishingly unlikely int isn't big enough, but this makes the
    intent clearer...
2023-01-10 Explain the crest-factor division by 2.
2023-01-10 Only capture 1024 samples when measuring amplitude.
    For the FM signals found on LaserDisc and videotape, this is plenty to
    get a reasonable idea of the signal amplitude, and it makes the cost of
    having the text amplitude display turned on insignificant.
2023-01-27 Update tab order in DomesdayDuplicator's dialogs.
2023-02-26 Fix per-side naming logic.
    Fetching the per-side fields from the arrays when deciding the filename
    isn't correct, and the arrays were too short.
2023-03-19 Remove C-style (void) meaning no arguments.
    This is needed in C because () means any arguments are permitted, but in
    C++ () always means no arguments.
2023-03-19 Simplify amplitude display configuration.
    Make the style of the text labels match the rest of the UI (i.e. don't
    capitalise every word), and don't use radio buttons when there are only
    two options to choose from.
2023-03-19 Add settings to enable/disable per-side notes and mint marks.
    These are individually configurable because it's reasonable to want one
    but not the other (e.g. if you're using the notes field to record the
    player used).
2023-03-19 Reorder setup code to match the dialog.
2023-03-19 Add missing code to reset amplitude settings to defaults.
    It's a bit awkward having this in two places anyway; it'd be nicer if it
    could just load it from a default Configuration.
2023-07-26 Avoid duplicate QVBoxLayout names.
    This is harmless, but Qt 6 warns about it.
2024-01-10 Added MacOS support
    Minimum changes to allow Domesday to compile and run under MacOS.
    Linux-Application % cmake .
    -- The C compiler identification is AppleClang 14.0.0.14000029
    -- The CXX compiler identification is AppleClang 14.0.0.14000029
    -- Detecting C compiler ABI info
    -- Detecting C compiler ABI info - done
2024-11-03 Major refactor of application, with new USB communication back-end.
    -Rewrote all USB communication code
    -Added direct support for WinUSB on Windows
    -Fixed data corruption issues on Windows/Linux
    -Added the ability to send manual player serial control commands
    -Added .json metadata file to accompany captures
    -Added support for selecting between multiple USB devices
2024-11-03 Tidied up some comments and log messages
2024-11-03 Dropped Qt5 from github pipeline
    Qt5 holds us back from C++20 features, and it's not relevant in 2024.
2025-02-05 Visualise readme, add basic context info, update formatting.
    Ending the 1-click lost lamb situation, with better information resource linkage.
2025-02-05 Add 3D printed case image assets
2025-02-05 Add 3D Printed case info
2025-03-05 Update UsbDeviceBase.cpp
    Hack fix to prevent "Use of undeclared identifier 'bufferCount'" while building on macOS
2025-09-04 Improvements to capture stats, metadata, and file naming. Added user code retrieval.
2025-09-04 Fix for ambiguous overload on linux
2025-09-04 Fixed dependence on qt 6.5 library feature unavailable on linux target
2025-09-04 Fixed a missing change from the previous commit
2025-09-04 Fixed missing include headers breaking linux compilation
2025-09-04 Made display of advanced capture statistics optional
2025-09-04 add inital binary build workflow
    automatically build application binary's for all platforms X86/ARM
2025-10-11 Add missing #include
    This file uses uint*_t.
2025-10-11 Fix typo in JSON output
    "playerVersionNumber" was misspelled as "playerVesionNumber".
2025-12-08 Make Documentation Great Again
2025-12-08 Add broken link detection script and remove broken links it detected
2025-12-08 Add orphan check, update testing page and rename bad filenames
2025-12-08 Add ld-decode to the decode family section (as it was oddly missing)
2025-12-08 Added links and page about how to help with the documentation site
2025-12-08 Linkage fix
2025-12-08 Clean up of various pages (mostly missing titles)
2025-12-08 Removed 21 spelling errors
2025-12-08 Automated clean up of markdown whitespace and other minor issues
2025-12-08 Added new section on EFM decode tools
2025-12-08 Fix a link in the old ld-process-efm document
2025-12-09 Added automatic broken link and orphan checking in CI/CD deployment
2025-12-09 Link to vhs-decode for pre-built binaries
2025-12-09 Improved show-external links script to actually test the links and see if they 404
2025-12-09 Moved in the DdD wiki to the website
2025-12-09 Correct the base_url
2025-12-09 Get rid of all the unnecessary related-project pages
2025-12-09 Minor fix to the index page
2025-12-09 Modify readme and create contributing readme
2025-12-10 Extract hardware, firmware, and gui into separate submodules
2025-12-10 Add hardware, firmware, and gui-app as submodules
2025-12-10 Added correct git clone command to README.md
2025-12-10 Add README.md to sub-modules
2025-12-10 Fix firmware submodule pointer to current valid commit
2025-12-10 Update readme, local images, remove duplication document
2025-12-10 Add documentation sub-module
2025-12-10 Add README.md with submodule reference
2025-12-10 Update submodules with README files
2025-12-10 Fix build environment and move to Qt6
2025-12-10 FIxed some build warnings - removed repeating USB messages from console
2025-12-10 Removed MIT licensed JSON library. Removed amplitude JSON (it's already in the sample...). Stopped constant player status output (only when status changes). Disabled all player related JSON when play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
2025-12-10 Get rid of annoying DisconnectFromDevice critical error on exit
2025-12-10 Remove binary building (putting it in the gui-app sub-module instead)
2025-12-10 Add cross-platform GitHub Actions build workflow for gui-app
2025-12-10 Move to new gui-app commit
2025-12-10 Remove build scripts (as they are now in gui-apps)
2025-12-11 Changed build to cmake. Moved to FX3 1_3_5 sdk. Added CI/CD FX3 firmware build test
2025-12-11 Fix fedora build test
2025-12-11 Move to the latest FX3 firmware
2025-12-11 Restructure FX3 firmware and implement minimal programmer tool
    - Reorganize directory structure: fx3/fx3-firmware and fx3/fx3-programmer
    - Implement new FX3 programmer tool:
    * Minimal CLI tool using libusb-1.0 only (no Qt dependency)
    * Discover FX3 bootloader and application mode devices
    * Proper bootloader protocol implementation (USB vendor command 0xA0)
    * Firmware binary format parsing and upload with error reporting
2025-12-11 Remove old fx3-firmware root directory structure (moved to fx3/fx3-firmware)
2025-12-11 Add fx3-programmer build to CI/CD workflow
    - Add libusb-1.0-0-dev and libusb1-devel dependencies to Ubuntu and Fedora builds
    - Configure and build fx3-programmer in both Ubuntu and Fedora environments
    - Upload fx3-programmer binary as build artifact alongside firmware
    - Verify both firmware and programmer binaries with file command
2025-12-11 Improve FX3 suspend handling and programmer verify

Notices in the files:
KiCAD/Domesday Duplicator/Domesday Duplicator.kicad_pcb:
(c)2018 Simon Inns
License: Attribution-ShareAlike 4.0 International (CC BY-SA 4.0)
